options:
  parameters:
    generate_options: qt_gui
    id: FM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 200e3
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: 88.5e6
    gain: '40.0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_1, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [soapy_bladerf_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
