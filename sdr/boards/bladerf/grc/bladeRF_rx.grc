options:
  parameters:
    author: Nuand, LLC <bladeRF@nuand.com>
    category: Custom
    description: A simple RX-only GUI that demonstrates the usage of various RX controls.
    generate_options: qt_gui
    id: bladeRF_rx
    output_language: python
    title: '"Simple bladeRF RX GUI"'
  states: {}

blocks:
- name: bladerf_args
  id: variable
  parameters:
    value: '"bladerf=" + bladerf_selection + ",buffers=" + str(num_buffers) + ",buflen=" + str(buflen) + ",num_xfers=" + str(num_xfers) + ",verbosity="+verbosity'
  states: {}
- name: bladerf_selection
  id: variable
  parameters:
    value: str(instance) if serial == "" else serial
  states: {}
- name: gui_bladerf_args
  id: variable_qtgui_label
  parameters:
    gui_hint: 11, 0, 1, 10
    label: '"bladeRF arguments"'
    type: string
    value: bladerf_args
  states: {}
- name: gui_dc_offset_i
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 4, 1, 2
    label: I DC Offset
    start: '-1.0'
    step: (1.0 / 2048.0)
    stop: '1.0'
    value: dc_offset_i
  states: {}
- name: gui_dc_offset_q
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 6, 1, 2
    label: Q DC Offset
    start: '-1.0'
    step: (1.0 / 2048.0)
    stop: '1.0'
    value: dc_offset_q
  states: {}
- name: gui_rx_bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 2, 1, 2
    label: Bandwidth
    start: 1.5e6
    step: 0.5e6
    stop: 28e6
    value: rx_bandwidth
  states: {}
- name: gui_rx_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 5
    label: Frequency
    start: '0'
    step: 1e6
    stop: 3.8e9
    value: rx_frequency
  states: {}
- name: gui_rx_lna_gain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0, 9, 1, 1
    label: LNA Gain
    label0: 0 dB
    label1: 3 dB
    label2: 6 dB
    num_opts: '3'
    option0: '0'
    option1: '3'
    option2: '6'
    type: int
    value: rx_lna_gain
  states: {}
- name: gui_rx_sample_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 2
    label: Sample Rate
    start: 1.5e6
    step: 500e3
    stop: 40e6
    value: rx_sample_rate
  states: {}
- name: gui_rx_vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 5, 1, 4
    label: RX VGA1 + VGA2 Gain
    start: '5'
    step: '1'
    stop: '60'
    value: rx_vga_gain
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: gui_dc_offset_i
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: gui_dc_offset_q
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: buflen
  id: parameter
  parameters:
    label: Length of buffers, in samples. Should be a multiple of 1024.
    value: '4096'
  states: {}
- name: dc_offset_i
  id: parameter
  parameters:
    label: DC offset compensation for I channel
    type: eng_float
    value: '0'
  states: {}
- name: dc_offset_q
  id: parameter
  parameters:
    label: DC offset compensation for Q channel
    type: eng_float
    value: '0'
  states: {}
- name: instance
  id: parameter
  parameters:
    label: 0-indexed device instance describing device to use. Ignored if a serial-number is provided.
    type: intx
    value: '0'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Command line params
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: GUI Controls
  states: {}
- name: note_1
  id: note
  parameters:
    note: When enabling the fosphor sink, disable the Qt Frequency and Waterfall sinks.
  states: {}
- name: note_2
  id: note
  parameters:
    note: 'TO DO:  Expose bladeRF''s internal DC offset compensation in the gr-osmosdr block and use this instead.'
  states: {}
- name: num_buffers
  id: parameter
  parameters:
    label: Number of buffers to use
    type: intx
    value: '16'
  states: {}
- name: num_xfers
  id: parameter
  parameters:
    label: Number of maximum in-flight USB transfers. Should be <= (num-buffers / 2).
    type: intx
    value: '8'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: gui_rx_sample_rate
    fc: gui_rx_frequency
    fftsize: '8192'
    gui_hint: 2, 0, 5, 5
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 7, 0, 3, 10
    label1: ''
    label2: ''
    size: '8192'
    srate: rx_sample_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: gui_rx_sample_rate
    fc: gui_rx_frequency
    fftsize: '8192'
    gui_hint: 2, 5, 5, 5
    showports: 'True'
    type: complex
  states: {}
- name: rx_bandwidth
  id: parameter
  parameters:
    label: Bandwidth
    short_id: b
    type: eng_float
    value: 1.5e6
  states: {}
- name: rx_frequency
  id: parameter
  parameters:
    label: Frequency
    short_id: f
    type: eng_float
    value: 915e6
  states: {}
- name: rx_lna_gain
  id: parameter
  parameters:
    label: RX LNA Gain
    short_id: l
    type: intx
    value: '6'
  states: {}
- name: rx_sample_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: 3e6
  states: {}
- name: rx_vga_gain
  id: parameter
  parameters:
    label: RX VGA1 + VGA2 Gain
    short_id: g
    type: intx
    value: '20'
  states: {}
- name: serial
  id: parameter
  parameters:
    label: bladeRF serial number
    value: '""'
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: 88.5e6
    samp_rate: 1e6
    type: fc32
  states: {}
- name: verbosity
  id: parameter
  parameters:
    label: 'libbladeRF log verbosity. Options are: verbose, debug, info, warning, error, critical, silent'
    value: '"info"'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_add_const_vxx_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_bladerf_source_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
