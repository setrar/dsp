options:
  parameters:
    author: MWK
    generate_options: qt_gui
    id: fm_receiver_MWK
    output_language: python
    title: fm_receiver_MWK
  states: {}

blocks:
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 88.1e6
    step: 100e3
    stop: 107.9e6
    value: 92.2e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: RG Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(samp_rate/channel_width)
    quad_rate: channel_width
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '44100'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: int(samp_rate/channel_width)
    samp_rate: samp_rate
    taps: '0'
    type: ccc
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    showrf: 'True'
    type: complex
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
